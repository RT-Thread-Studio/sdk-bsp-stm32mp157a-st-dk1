# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP157A_M4 ST STM32MP157A_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; NO_ATOMIC_64_SUPPORT; METAL_INTERNAL; METAL_MAX_DEVICE_REGIONS=2; VIRTIO_SLAVE_ONLY; STM32MP157Axx; __LOG_TRACE_IO_; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: libraries\HAL_Drivers\config; libraries\STM32MPxx_HAL\STM32MP1xx_HAL_Driver\Inc; rt-thread\include; libraries\HAL_Drivers; board\CubeMX_Config\CM4\Inc; board\ports; libraries\STM32MPxx_HAL\CMSIS\Core\Include; rt-thread\libcpu\arm\common; rt-thread\libcpu\arm\cortex-m4; rt-thread\components\finsh; .; applications; rt-thread\components\drivers\include; board; libraries\STM32MPxx_HAL\CMSIS\Include; libraries\STM32MPxx_HAL\CMSIS\Device\ST\STM32MP1xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.bin
  ILINK.IlinkOutputFile: RT-Thread-STM32MP1_CM4.elf
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Common/System/: system_stm32mp1xx.c
    board/CubeMX_Config/CM4/Src/: stm32mp1xx_hal_msp.c
    libraries/STM32MPxx_HAL/CMSIS/Device/ST/STM32MP1xx/Source/Templates/iar/: startup_stm32mp15xx.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group STM32_HAL
    libraries/STM32MPxx_HAL/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_exti.c stm32mp1xx_hal_ipcc.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_mdma.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_adc.c stm32mp1xx_hal_adc_ex.c stm32mp1xx_hal_dac.c stm32mp1xx_hal_dac_ex.c stm32mp1xx_hal_i2c.c stm32mp1xx_hal_i2c_ex.c stm32mp1xx_hal_spi.c stm32mp1xx_hal_tim.c stm32mp1xx_hal_tim_ex.c stm32mp1xx_hal_uart.c stm32mp1xx_hal_uart_ex.c
